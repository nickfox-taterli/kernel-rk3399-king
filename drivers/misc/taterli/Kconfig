## drivers/misc/taterli/Kconfig
```kconfig
config TATERLI
	tristate "TaterLi Misc Driver support"
	default n
	---help---
	  I'm Lazy!
```
